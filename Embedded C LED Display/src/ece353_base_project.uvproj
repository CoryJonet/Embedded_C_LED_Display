# Keil uVision project ece353_base_project.uvproj, settings and files
target base_project (ARM-ADS)
  device: LM4F120E5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: ece353_base_project
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\ece353.sct
  group src
    ./: Startup.s main.c initBoard.c systick.c hw4_adc.c hw4_gpio.c led_chars.c
  group Lib
    ./lib/: pll.lib uart.lib gpio.lib portC_init.lib
